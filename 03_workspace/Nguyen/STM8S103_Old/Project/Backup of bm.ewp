# IAR project Backup of bm.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: E:\workspaceNew\STM8_BaseMachine\Libraries\inc; E:\workspaceNew\STM8_BaseMachine\User
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ILINK.IlinkOutputFile: bm.out
  group Driver
    ../User/: bh1750.c ds1307.c gpio.c i2c.c pwm.c sht1x.c timer.c uart.c
  group Layers
    ../User/: layerHardware.c stateMachine.c
  group Main
    ../User/: defineHardware.h stm8s_conf.h
    ./: main.c
  group StdPeriph
    ../Libraries/src/: stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_iwdg.c stm8s_tim1.c stm8s_tim2.c stm8s_uart1.c
