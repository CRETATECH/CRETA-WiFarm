# IAR project Backup of STM8S103.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: E:\workspaceNew\STM8S103\2_StdPeriph\inc; E:\workspaceNew\STM8S103\3_User\1_HAL; E:\workspaceNew\STM8S103\3_User\2_Driver; E:\workspaceNew\STM8S103\3_User\3_Framework; E:\workspaceNew\STM8S103\3_User\4_StateMachine; E:\workspaceNew\STM8S103\3_User\5_Main
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: STM8S103.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG; STM8S103
  group StdPeriph
    ../2_StdPeriph/src/: stm8s_clk.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_tim2.c stm8s_uart1.c
  group User/Driver
    ../3_User/2_Driver/: button.c defineHardware.h device.c ds1307.c sht1x.c
  group User/Framework
    ../3_User/3_Framework/: rtc.c serialProtocol.c
  group User/HAL
    ../3_User/1_HAL/: eeprom.c gpio.c i2c.c timer.c uart.c
  group User/Main
    ../3_User/5_Main/: main.c stm8s_conf.h
  group User/StateMachine
    ../3_User/4_StateMachine/: StateMachine.c
