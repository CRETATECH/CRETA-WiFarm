# IAR project test.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: ..; ..\Library\inc; ..\User\2_gpio; ..\User\3_I2C; ..\User\4_DS1307
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: test.srec
  ILINK.IlinkOutputFile: test.hex
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Library
    ../Library/src/: stm8s_clk.c stm8s_gpio.c stm8s_i2c.c
  group User/1_main
    ../User/1_main/: main.c
  group User/2_gpio
    ../User/2_gpio/: gpio.c gpio.h
  group User/3_I2C
    ../User/3_I2C/: I2C.c I2C.h
  group User/4_DS1307
    ../User/4_DS1307/: DS1037.c DS1037.h
