# IAR project STM8_Slave.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: ..\2_StdPeriph\inc; ..\3_User\1_HAL; ..\3_User\2_Driver; ..\3_User\3_Framework; ..\3_User\4_StateMachine; ..\3_User\5_Main
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: STM8_Slave.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Driver
    ../3_User/2_Driver/: button.c buzzer.c defineHardware.h device.c dhtxx.c ds1307.c lcd.c sht1x.c
  group Framework
    ../3_User/3_Framework/: rtc.c serialProtocol.c
  group HAL
    ../3_User/1_HAL/: eeprom.c gpio.c i2c.c timer.c uart.c
  group Main
    ../3_User/5_Main/: main.c stm8s_conf.h
  group StateMachine
    ../3_User/4_StateMachine/: StateMachine.c
  group StdPeriph
    ../2_StdPeriph/src/: stm8s_adc1.c stm8s_clk.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_tim2.c stm8s_uart1.c
