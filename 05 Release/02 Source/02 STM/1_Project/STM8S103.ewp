# IAR project STM8S103.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: ..\2_StdPeriph\inc; ..\3_User\1_HAL; ..\3_User\2_Driver; ..\3_User\3_Framework; ..\3_User\4_StateMachine; ..\3_User\5_Main
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: STM8S103.hex
  ILINK.IlinkOutputFile: STM8S103.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG; STM8S103
  group StdPeriph
    ../2_StdPeriph/src/: stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_iwdg.c stm8s_tim2.c stm8s_tim4.c stm8s_uart1.c
  group User/Driver
    ../3_User/2_Driver/: button.c buzzer.c defineHardware.h device.c dhtxx.c ds1307.c sht1x.c
  group User/Framework
    ../3_User/3_Framework/: rtc.c serialProtocol.c
  group User/HAL
    ../3_User/1_HAL/: eeprom.c gpio.c i2c.c timer.c uart.c
  group User/Main
    ../3_User/5_Main/: main.c stm8s_conf.h
  group User/StateMachine
    ../3_User/4_StateMachine/: StateMachine.c
